# Keil uVision project rbc_mesh_template.uvprojx, settings and files
target nRF51822 xxAA (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rbc_mesh +hex
  c flags: Optim=1 wLevel=2
  c define: BOARD_PCA10028 NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT SMART_VALVE
  c misc: --c99
  c include: ..\include;..\..\..\rbc_mesh;..\..\..\rbc_mesh\include;..\..\..\SDK\bsp;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\toolchain\gcc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\softdevice\common\softdevice_handler
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20003000 size 0x5000
  group app
    ../: main.c nrf_adv_conn.c
  group rbc_mesh
    ../../../rbc_mesh/src/: radio_control.c rbc_mesh.c timer_control.c timeslot_handler.c trickle.c transport_control.c mesh_aci.c serial_handler_spi.c fifo.c event_handler.c version_handler.c mesh_packet.c mesh_gatt.c bootloader_info_app.c bootloader_app.c bootloader_util.c rand.c simple_uart.c
  group core
    ./: system_nrf51.c arm_startup_nrf51.s
  group lib
    ../../../../../../components/drivers_nrf/spi_slave/: spi_slave.c
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
    ../../../../../../components/ble/common/: ble_advdata.c
target nRF51822 xxAA serial (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.1
  cpu: as above
  output: rbc_mesh_led_pca10001 +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: BOARD_PCA10028 NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT RBC_MESH_SERIAL
  c include: as above
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
