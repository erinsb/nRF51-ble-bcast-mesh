# Keil uVision project rbc_mesh_BLE_Gateway.uvprojx, settings and files
target nRF51822 xxAA (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.1
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rbc_gateway_example +hex
  c flags: Optim=1 wLevel=2
  c define: BOARD_PCA10028 NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\include;..\..\..\rbc_mesh;..\..\..\rbc_mesh\include;..\..\..\SDK\bsp;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\toolchain\gcc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\softdevice\s110\headers
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x2c000
  memory RVCT9: RAM 0x20004000 size 0x4000
  link misc: --callgraph
  group app
    ../: main.c nrf_adv_conn.c led_config.c
  group rbc_mesh
    ../../../rbc_mesh/src/: radio_control.c rbc_mesh.c timer_control.c timeslot_handler.c trickle.c mesh_gatt.c transport_control.c mesh_aci.c serial_handler_spi.c fifo.c event_handler.c version_handler.c mesh_packet.c bootloader_util.c bootloader_app.c rand.c bootloader_info_app.c simple_uart.c
    ../: gpio_config.c
  group core
    ./: arm_startup_nrf51.s system_nrf51.c
  group lib
    ../../../../../../components/ble/common/: ble_advdata.c
    ../../../../../../components/drivers_nrf/spi_slave/: spi_slave.c
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
target nRF51822 xxAA serial (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rbc_gateway_example_serial +hex
  c flags: Optim=1 wLevel=2
  c define: BOARD_PCA10028 NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT RBC_MESH_SERIAL DEBUG
  c misc: --c99
  c include: ..\include;..\..\..\rbc_mesh;..\..\..\rbc_mesh\include;..\..\..\SDK\bsp;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\toolchain\gcc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\softdevice\common\softdevice_handler
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x18000
  memory RVCT9: RAM 0x20003000 size 0x5000
target nRF51822 xxAA buttons (ARM-ADS)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.1
  cpu: as above
  output: rbc_gateway_example +hex
  c flags: Optim=1 wLevel=2
  c define: BOARD_PCA10028 NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT BUTTONS
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
